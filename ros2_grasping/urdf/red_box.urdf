Commit message: add color detection and more boxes

File: ros2_grasping/urdf/red_box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- removed link box
- added link red_box, mass 0.1; collision box size=0.04 0.04 0.08; visual box size=0.04 0.04 0.08
